Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-12-23T11:53:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161117_1200(x64) - Exporter 17.0.1099.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 23 11:53:04 2016 * Host: WITAS2 * Database: C:\Users\WITAS_~1\AppData\Local\Temp\{9C6B1873-8456-4184-A42A-AFB560F96B09}\ifc * Database version: 5507 * Database creation date: Fri Dec 23 11:53:04 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 23 11:53:04 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 23 11:53:04 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: E62 LED4N60S, Dummy:E62 LED4N60S:208399
In: Level 1
Type - Material: BE Armatuur, BE_G Reflector, BERSnl_glas lamp
Type - Constraints - Default Elevation: 2000 mm; WT_H Behuizing: Standaard; WT_H Bevestiging: Geen; WT_H Coarse geometrie: Standaard; WT_H Opbouw: yes; WT_H Pendel horizontale armatuurmontage: no; WT_H Referentie: Opbouw; WT_H Symbool plafond hoogte: 0 mm; WT_H Symbool plafond lengte: 1640 mm; WT_H Symbool wand hoogte: 0 mm; WT_H Symbool wand lengte: 1640 mm
Type - Dimensions - BE_G Breedte: 56 mm; BE_G Diameter: 0 mm; BE_G Hoogte: 80 mm; BE_G Lengte: 1640 mm
Type - Electrical - BE_E Arbeidsfactor: 1; BE_E Belastingsklasse: Verlichting; BE_E Schijnbaar vermogen: 568 W; BE_E Spanning: 230 V
Type - Electrical - Loads - Apparent Load: 568 W
Type - Graphics - WT_V Symbool plafond: rectangular - luminaire - led; WT_V Symbool wand: none_gen
Type - Identity Data - BE_I Bestelcode: E62/LED4N60S; Manufacturer: ETAP; Model: E62; Type Name: E62 LED4N60S; WT_I BaseKeynote: 63.1
Type - Materials and Finishes - WT_V Materiaal armatuur: BE Armatuur
Type - Model Properties - WT_I Armatuurrendement: 0; WT_I IP klasse: IP66; WT_I Kleur: RAL7037; WT_I Lampkleur: 4000; WT_I Lichtstroom armatuur: 5936; WT_I Maatschets catalogus: -; WT_I Maximale temperatuur: 850°C; WT_I Montage: Plafond; WT_I Optiek: lens; WT_I Type: individueel; WT_I UGR: <=28; WT_I Voorschakelapparaat: S; WT_I Vorm: langwerpig
Type - Other - Category: Lighting Fixtures; Family Name: Dummy; WT_c1 Omschrijving: c1_Elektrische voeding
Type - Photometrics - WT_H Lichtbron: BE_E_GEO Armatuur_ETAP E62 - lichtbron: E62_LED4N60_S; WT_I Aantal lampen: 1; WT_I Afschermhoek: 0 deg; WT_I Lamptype: Low PowerLed; WT_I Luminantie: 0; WT_I Vermogen lamp: 568 W
Pset_ManufacturerTypeInformation - Manufacturer: ETAP
Pset_DistributionFlowElementCommon - Reference: E62 LED4N60S
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; WT_H Offset lichtbron: 40 mm; WT_H Pendelhoogte: 40 mm
Construction - WT_V Pendelhoogte: 0 mm
Dimensions - Area: 0.187617 m2; Volume: 0.00624346 m3
Electrical - Circuiting - Electrical Data: c1_Elektrische voeding 230 V/1-568 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 7
Other - Family: Dummy: E62 LED4N60S; Family and Type: Dummy: E62 LED4N60S; Schedule Level: Level: Level 1; Type: Dummy: E62 LED4N60S; Type Id: Dummy: E62 LED4N60S
Phasing - Phase Created: 64113
